# Keil uVision project ODDSUM.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C5131 Microchip
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(32000000) MODP2
  output: ODDSUM
  c flags: Optimize=8 SizeSpeed=1
  group OddSum
    ./: sum_of_all_the_odd_numbers.asm
