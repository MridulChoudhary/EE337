# Keil uVision project UART_Master.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C5131A Microchip
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(32000000) MODP2
  output: UART_Master +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: serial.h spi.h SPI_Master.c STARTUP.A51
