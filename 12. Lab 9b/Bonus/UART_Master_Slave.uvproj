# Keil uVision project UART_Master_Slave.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C5131A Microchip
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(32000000) MODP2
  output: SPI_Slave +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 serial.h spi.h lcd.h SPI_Slave.c
    ../Lab_9B_Part2/: ADDITION.asm
