ORG 0H
LJMP MAIN
ORG 100H
MAIN:
CALL MAC
HERE: SJMP HERE
ORG 130H
// *****************

MAC:
	MOV 50H, #00H
	MOV 51H, #00H
	MOV 52H, #00H
	MOV A, 70H
	MOV B, 73H
	MUL AB
	CALL ADD16
	MOV A, 71H
	MOV B, 74H
	MUL AB
	CALL ADD16
	MOV A, 72H
	MOV B, 75H
	MUL AB
	CALL ADD16
	// MAC OPERATION, CALL THE ADDITION SUBROUTINE USING "CALL ADD16"
RET
ADD16:

	ADD A, 52H
	MOV 52H, A
	MOV A, B
	ADDC A, 51H
	MOV 51H, A
	MOV A, R1
	ADDC A, R1
	ADD A, 50H
	MOV 50H, A
// ADD16 SUBROUTINE FROM PREVIOUS LAB
RET
END