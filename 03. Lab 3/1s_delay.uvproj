# Keil uVision project 1s_delay.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C5131A Microchip
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x7FFF) CLOCK(32000000) MODP2
  output: 1s_delay +hex
  c flags: Optimize=8 SizeSpeed=1
  group 1s_delay
    ./: delay_1s.asm
